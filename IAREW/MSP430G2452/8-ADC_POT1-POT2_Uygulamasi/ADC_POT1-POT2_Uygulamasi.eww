<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\ADC_POT1-POT2_Uygulamasi.ewp</path>
  </project>
  <batchBuild/>
</workspace>


