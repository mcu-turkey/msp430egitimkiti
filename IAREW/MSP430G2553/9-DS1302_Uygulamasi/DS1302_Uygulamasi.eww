<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\DS1302_Uygulamasi.ewp</path>
  </project>
  <batchBuild/>
</workspace>


